# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\CORE;..\HALLIB\Inc;..\USER;..\SYSTEM_OEDA\delay;..\SYSTEM_OEDA\sys;..\SYSTEM_OEDA\usart;..\HARDWARE\BASIC\ESC\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM_OEDA
    ../SYSTEM_OEDA/delay/: delay.c
    ../SYSTEM_OEDA/sys/: sys.c
    ../SYSTEM_OEDA/usart/: usart.c
  group CORE
    ../CORE/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h startup_stm32f407xx.s
  group HALLIB
    ../HALLIB/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group HARDWARE
    ../HARDWARE/BASIC/ESC/src/: ESC.c
